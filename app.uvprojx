# Keil uVision project app.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: copy.bat
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\hex\new.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_USB_FS,GD32F407
  c include: .\app;.\app\inc;.\bsp\inc;.\include\GD32F4;.\usb;.\usb\driver\Include;.\usb\device\core\Include;.\usb\device\class\cdc\Include;.\usb\ustd\common;.\usb\ustd\class\cdc;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\obj\app.sct
  group app
    ./app/: main.c gd32f4xx_it.c
    ./app/src/: usr_app.c usr_atv.c usr_aw.c usr_comip.c usr_dev.c usr_flash.c usr_fota.c usr_gpio.c usr_gps.c usr_gsm.c usr_handset.c usr_hook.c usr_ibutton.c usr_mile.c usr_msg.c usr_printf_stdarg.c usr_public.c usr_ring_buffer.c usr_rtc.c usr_serialoil.c usr_sleep.c usr_sms.c usr_softdog.c usr_stdlib.c usr_sys.c usr_timer.c usr_usb.c
    ./usb/: gd32f4xx_hw.c
  group bsp
    ./bsp/src/: bsp_adc.c bsp_dwt.c bsp_gpio.c bsp_iap.c bsp_iwdg.c bsp_nvic.c bsp_spi.c bsp_timer.c bsp_uart.c
  group usb_driver
    ./usb/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group usb_device
    ./usb/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group usb_class
    ./usb/device/class/cdc/Source/: cdc_acm_core.c
  group freertos
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group lib
    ./lib/: GD32F4.lib
  group startup
    ./startup/: startup_gd32f407.s
